<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>169010000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>samp_rate</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>phase</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>np.pi/32</value></param>
<param><key>stop</key><value>2*np.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(4e6)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>size</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>192.168.10.120</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>server</key><value>True</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX1</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>RX2</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>A:AB B:AB</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
